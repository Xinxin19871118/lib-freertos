# IAR project lib-freertos-v821-stm32f4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\include; ..\portable\IAR\ARM_CM4F; ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src
  ILINK.IlinkOutputFile: lib-freertos-v821-stm32f4.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group core
    ../src/: list.c queue.c tasks.c timers.c
  group mm
    ../portable/MemMang/: heap_2.c
  group portable
    ../portable/IAR/ARM_CM4F/: port.c portasm.s
